FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
                file://dd.cfg \
                file://inetd.conf \
                "

